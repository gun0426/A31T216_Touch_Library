# Keil uVision project app.uvprojx, settings and files
target A31T21X (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_DEBUG=1 CONFIG_DEBUG_SERIAL_FIFO=1
  c include: ..\..\a31t21x;..\..\..\..\..\core\cmsis\include;..\..\..\..\..\core\device\a31t21x\include;..\..\..\..\..\driver\a31t21x\include;..\..\..\..\..\library\debug\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x20003000 size 0x1000
  group app
    ../../: main.c
    ../: a31t21x_system_setting.c a31t21x_debug.c a31t21x_port_init.c
  group core
    ../../../../../core/device/a31t21x/source/: a31t21x_system.c a31t21x_startup_arm.s
  group driver
    ../../../../../driver/a31t21x/source/: a31t21x_dma.c a31t21x_fmc.c a31t21x_gpio.c a31t21x_scu.c a31t21x_uart.c
  group library
    ../../../../../library/debug/source/: debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
