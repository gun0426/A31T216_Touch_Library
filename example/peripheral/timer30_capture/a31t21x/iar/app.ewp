# IAR project app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: A31T216 ABOV A31T216
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CONFIG_DEBUG=1; CONFIG_DEBUG_SERIAL_FIFO=1
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..; ..\..\..\..\..\core\cmsis\include; ..\..\..\..\..\core\device\a31t21x\include; ..\..\..\..\..\driver\a31t21x\include; ..\..\..\..\..\library\debug\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app.srec
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ABOV\A31T216.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../: a31t21x_debug.c a31t21x_port_init.c a31t21x_system_setting.c
    ../../: main.c
  group core
    ../../../../../core/device/a31t21x/source/: a31t21x_startup_iar.s a31t21x_system.c
  group driver
    ../../../../../driver/a31t21x/source/: a31t21x_dma.c a31t21x_gpio.c a31t21x_scu.c a31t21x_timer.c a31t21x_timer30.c a31t21x_uart.c
  group library
    ../../../../../library/debug/source/: debug_cmd.c debug_hardfault.c debug_log.c debug_retarget.c debug_serial.c
