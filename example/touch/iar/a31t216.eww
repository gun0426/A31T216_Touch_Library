<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\a31t216.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\code_lib\touch.ewp</path>
    </project>
    <batchBuild />
</workspace>
