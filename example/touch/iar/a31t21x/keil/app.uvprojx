# Keil uVision project app.uvprojx, settings and files
target A31T21X (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  c flags: Optim=1 uC99=1
  c include: ..\..\..\..\..\core\device\a31t21x\include;..\..\..\..\..\driver\a31t21x\include;..\..\code_app\library\header;..\..\common;..\..\..\..\..\core\cmsis\include
  memory RVCT4: ROM 0x0 size 0x3ffff
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x20003000 size 0x1000
  group app
    ../../code_app/: main.c a31t21x_system_setting.c a31t21x_port_init.c debug.c led_driver.c user.c
    ../../code_lib/: touch.c user_timer.c
    ../../code_app/library/Objects/: touch.lib
  group core
    ../../../../../core/device/a31t21x/source/: a31t21x_system.c a31t21x_startup_arm.s
  group driver
    ../../../../../driver/a31t21x/source/: a31t21x_adc.c a31t21x_crc.c a31t21x_dma.c a31t21x_fmc.c a31t21x_fmc_self.c a31t21x_gpio.c a31t21x_i2c.c a31t21x_lcd.c a31t21x_led.c a31t21x_pwr.c a31t21x_scu.c a31t21x_spi.c a31t21x_timer.c a31t21x_timer30.c a31t21x_uart.c a31t21x_usart1n.c a31t21x_wdt.c a31t21x_wt.c
