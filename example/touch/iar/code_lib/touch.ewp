# IAR project touch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: A31T216 ABOV A31T216
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\..\core\cmsis\include; ..\..\..\..\core\device\a31t21x\include; ..\..\..\..\driver\a31t21x\include; ..\code_app\library\header
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: touch.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: touch.c user_timer.c
