# Keil uVision project lib.uvprojx, settings and files
target A31T21X (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: touch +hex (library)
  c flags: Optim=1
  c include: ..\..\..\..\..\core\cmsis\include;..\..\..\..\..\core\device\a31t21x\include;..\..\..\..\..\driver\a31t21x\include;..\..\code_app\library\header;..\..\common
  memory RVCT4: ROM 0x0 size 0x3ffff
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x20003000 size 0x1000
  group lib
    ../../code_lib/: touch.c user_timer.c
